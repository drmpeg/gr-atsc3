options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: vv001
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: atsc3_bbscrambler_bb_0
  id: atsc3_bbscrambler_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_bch_bb_0
  id: atsc3_bch_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_interleaver_bb_0
  id: atsc3_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_ldpc_bb_0
  id: atsc3_ldpc_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: tp09.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: tp09u.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: tp08.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: tp05.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}

connections:
- [atsc3_bbscrambler_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [atsc3_bch_bb_0, '0', atsc3_ldpc_bb_0, '0']
- [atsc3_interleaver_bb_0, '0', blocks_file_sink_0_0, '0']
- [atsc3_interleaver_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [atsc3_ldpc_bb_0, '0', atsc3_interleaver_bb_0, '0']
- [atsc3_ldpc_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', atsc3_bbscrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', atsc3_bch_bb_0, '0']

metadata:
  file_format: 1
