options:
  parameters:
    author: drmpeg
    generate_options: qt_gui
    id: vv320
    output_language: python
    title: ATSC 3.0 LDM Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 384000 * (16 + 2)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '89'
    value: '50'
  states: {}
- name: atsc3_alpbbheader_bb_0
  id: atsc3_alpbbheader_bb
  parameters:
    framesize: FECFRAME_NORMAL
    llsmode: LLS_OFF
    rate: C7_15
  states: {}
- name: atsc3_alpbbheader_bb_0_0
  id: atsc3_alpbbheader_bb
  parameters:
    framesize: FECFRAME_NORMAL
    llsmode: LLS_OFF
    rate: C10_15
  states: {}
- name: atsc3_bbscrambler_bb_0
  id: atsc3_bbscrambler_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C7_15
  states: {}
- name: atsc3_bbscrambler_bb_0_0
  id: atsc3_bbscrambler_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C10_15
  states: {}
- name: atsc3_bch_bb_0
  id: atsc3_bch_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C7_15
  states: {}
- name: atsc3_bch_bb_0_0
  id: atsc3_bch_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C10_15
  states: {}
- name: atsc3_bootstrap_cc_0
  id: atsc3_bootstrap_cc
  parameters:
    fftsize: FFTSIZE_16K
    flen: '100'
    flmode: FLM_SYMBOL_ALIGNED
    frameinterval: MTTN_250
    guardinterval: GI_4_768
    l1bmode: L1_FEC_MODE_1
    numpayloadsyms: '108'
    numpreamblesyms: '1'
    outputmode: BOOTSTRAP_INTERPOLATION
    pilotpattern: PILOT_SP8_2
    showlevels: SHOWLEVELS_OFF
    vclip: '3.3'
  states: {}
- name: atsc3_freqinterleaver_cc_0
  id: atsc3_freqinterleaver_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_16K
    firstsbs: SBS_ON
    guardinterval: GI_4_768
    mode: FREQ_ALL_SYMBOLS
    numpayloadsyms: '108'
    numpreamblesyms: '1'
    paprmode: PAPR_OFF
    pilotpattern: PILOT_SP8_2
  states: {}
- name: atsc3_interleaver_bb_0
  id: atsc3_interleaver_bb
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C7_15
  states: {}
- name: atsc3_interleaver_bb_0_0
  id: atsc3_interleaver_bb
  parameters:
    constellation1: MOD_64QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C10_15
  states: {}
- name: atsc3_ldmcombiner_cc_0
  id: atsc3_ldmcombiner_cc
  parameters:
    level: LDM_LEVEL_40DB
  states: {}
- name: atsc3_ldmframemapper_cc_0
  id: atsc3_ldmframemapper_cc
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_QPSK
    constellation3: MOD_64QAM
    constellation4: MOD_QPSK
    cred: CRED_0
    fecmode_core: PLP_FEC_BCH
    fecmode_enh: PLP_FEC_BCH
    fftsize: FFTSIZE_16K
    fimode: FREQ_ALL_SYMBOLS
    firstsbs: SBS_ON
    flen: '100'
    flmode: FLM_SYMBOL_ALIGNED
    framesize_core: FECFRAME_NORMAL
    framesize_enh: FECFRAME_NORMAL
    guardinterval: GI_4_768
    l1bmode: L1_FEC_MODE_1
    l1dmode: L1_FEC_MODE_1
    level: LDM_LEVEL_40DB
    llsmode_core: LLS_OFF
    llsmode_enh: LLS_OFF
    misomode: MISO_OFF
    numpayloadsyms: '108'
    numpreamblesyms: '1'
    paprmode: PAPR_OFF
    pilotboost1: SPB_0
    pilotboost10: SPB_0
    pilotboost11: SPB_0
    pilotboost12: SPB_0
    pilotboost13: SPB_0
    pilotboost14: SPB_0
    pilotboost15: SPB_0
    pilotboost16: SPB_0
    pilotboost2: SPB_0
    pilotboost3: SPB_0
    pilotboost4: SPB_0
    pilotboost5: SPB_0
    pilotboost6: SPB_0
    pilotboost7: SPB_4
    pilotboost8: SPB_0
    pilotboost9: SPB_0
    pilotpattern: PILOT_SP8_2
    rate_core: C7_15
    rate_enh: C10_15
    tiblocks: '2'
    tidepth: TI_DEPTH_1024
    tifecblocks: '14'
    tifecblocksmax: '14'
    timode: TI_MODE_CONVOLUTIONAL
  states: {}
- name: atsc3_ldpc_bb_0
  id: atsc3_ldpc_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C7_15
  states: {}
- name: atsc3_ldpc_bb_0_0
  id: atsc3_ldpc_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C10_15
  states: {}
- name: atsc3_modulator_bc_0
  id: atsc3_modulator_bc
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C7_15
  states: {}
- name: atsc3_modulator_bc_0_0
  id: atsc3_modulator_bc
  parameters:
    constellation1: MOD_64QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C10_15
  states: {}
- name: atsc3_pilotgenerator_cc_0
  id: atsc3_pilotgenerator_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_16K
    firstsbs: SBS_ON
    guardinterval: GI_4_768
    misomode: MISO_OFF
    misotxid: MISO_TX_1_OF_2
    numpayloadsyms: '108'
    numpreamblesyms: '1'
    outputmode: PILOTGENERATOR_TIME
    paprmode: PAPR_OFF
    pilotboost1: SPB_0
    pilotboost10: SPB_0
    pilotboost11: SPB_0
    pilotboost12: SPB_0
    pilotboost13: SPB_0
    pilotboost14: SPB_0
    pilotboost15: SPB_0
    pilotboost16: SPB_0
    pilotboost2: SPB_0
    pilotboost3: SPB_0
    pilotboost4: SPB_0
    pilotboost5: SPB_0
    pilotboost6: SPB_0
    pilotboost7: SPB_4
    pilotboost8: SPB_0
    pilotboost9: SPB_0
    pilotpattern: PILOT_SP8_2
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/re/ssd/rickmorty5_1atsc3.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /media/re/ssd/rickmorty6atsc3.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '768'
    input_size: '16384'
    tagname: ''
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, 3000000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [atsc3_alpbbheader_bb_0, '0', atsc3_bbscrambler_bb_0, '0']
- [atsc3_alpbbheader_bb_0_0, '0', atsc3_bbscrambler_bb_0_0, '0']
- [atsc3_bbscrambler_bb_0, '0', atsc3_bch_bb_0, '0']
- [atsc3_bbscrambler_bb_0_0, '0', atsc3_bch_bb_0_0, '0']
- [atsc3_bch_bb_0, '0', atsc3_ldpc_bb_0, '0']
- [atsc3_bch_bb_0_0, '0', atsc3_ldpc_bb_0_0, '0']
- [atsc3_bootstrap_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [atsc3_freqinterleaver_cc_0, '0', atsc3_pilotgenerator_cc_0, '0']
- [atsc3_interleaver_bb_0, '0', atsc3_modulator_bc_0, '0']
- [atsc3_interleaver_bb_0_0, '0', atsc3_modulator_bc_0_0, '0']
- [atsc3_ldmcombiner_cc_0, '0', atsc3_ldmframemapper_cc_0, '0']
- [atsc3_ldmframemapper_cc_0, '0', virtual_sink_0, '0']
- [atsc3_ldpc_bb_0, '0', atsc3_interleaver_bb_0, '0']
- [atsc3_ldpc_bb_0_0, '0', atsc3_interleaver_bb_0_0, '0']
- [atsc3_modulator_bc_0, '0', atsc3_ldmcombiner_cc_0, '0']
- [atsc3_modulator_bc_0_0, '0', atsc3_ldmcombiner_cc_0, '1']
- [atsc3_pilotgenerator_cc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [blocks_file_source_0, '0', atsc3_alpbbheader_bb_0, '0']
- [blocks_file_source_0_0, '0', atsc3_alpbbheader_bb_0_0, '0']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', atsc3_bootstrap_cc_0, '0']
- [virtual_source_0, '0', atsc3_freqinterleaver_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-402-g54d199a2
