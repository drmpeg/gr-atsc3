options:
  parameters:
    author: drmpeg
    generate_options: qt_gui
    id: vv410
    output_language: python
    title: ATSC 3.0 Subframe Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 384000 * (16 + 2)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '89'
    value: '50'
  states: {}
- name: atsc3_alpbbheader_bb_0
  id: atsc3_alpbbheader_bb
  parameters:
    framesize: FECFRAME_NORMAL
    llsmode: LLS_OFF
    rate: C9_15
  states: {}
- name: atsc3_alpbbheader_bb_1
  id: atsc3_alpbbheader_bb
  parameters:
    framesize: FECFRAME_NORMAL
    llsmode: LLS_OFF
    rate: C12_15
  states: {}
- name: atsc3_bbscrambler_bb_0
  id: atsc3_bbscrambler_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_bbscrambler_bb_0_0
  id: atsc3_bbscrambler_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C12_15
  states: {}
- name: atsc3_bch_bb_0
  id: atsc3_bch_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_bch_bb_0_0
  id: atsc3_bch_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C12_15
  states: {}
- name: atsc3_freqinterleaver_cc_0
  id: atsc3_freqinterleaver_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_8K
    firstsbs: SBS_OFF
    guardinterval: GI_5_1024
    mode: FREQ_ALL_SYMBOLS
    numpayloadsyms: '72'
    numpreamblesyms: '2'
    paprmode: PAPR_OFF
    pilotpattern: PILOT_SP3_4
  states: {}
- name: atsc3_freqinterleaver_cc_0_0
  id: atsc3_freqinterleaver_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_32K
    firstsbs: SBS_ON
    guardinterval: GI_4_768
    mode: FREQ_ALL_SYMBOLS
    numpayloadsyms: '18'
    numpreamblesyms: '0'
    paprmode: PAPR_OFF
    pilotpattern: PILOT_SP32_2
  states: {}
- name: atsc3_interleaver_bb_0
  id: atsc3_interleaver_bb
  parameters:
    constellation1: MOD_64QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_interleaver_bb_0_0
  id: atsc3_interleaver_bb
  parameters:
    constellation1: MOD_256QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C12_15
  states: {}
- name: atsc3_ldpc_bb_0
  id: atsc3_ldpc_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_ldpc_bb_0_0
  id: atsc3_ldpc_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C12_15
  states: {}
- name: atsc3_modulator_bc_0
  id: atsc3_modulator_bc
  parameters:
    constellation1: MOD_64QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_modulator_bc_0_0
  id: atsc3_modulator_bc
  parameters:
    constellation1: MOD_256QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C12_15
  states: {}
- name: atsc3_pilotgenerator_cc_0
  id: atsc3_pilotgenerator_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_8K
    firstsbs: SBS_OFF
    guardinterval: GI_5_1024
    misomode: MISO_OFF
    misotxid: MISO_TX_1_OF_2
    numpayloadsyms: '72'
    numpreamblesyms: '2'
    outputmode: PILOTGENERATOR_TIME
    paprmode: PAPR_OFF
    pilotboost1: SPB_0
    pilotboost10: SPB_0
    pilotboost11: SPB_0
    pilotboost12: SPB_0
    pilotboost13: SPB_0
    pilotboost14: SPB_0
    pilotboost15: SPB_0
    pilotboost16: SPB_0
    pilotboost2: SPB_4
    pilotboost3: SPB_0
    pilotboost4: SPB_0
    pilotboost5: SPB_0
    pilotboost6: SPB_0
    pilotboost7: SPB_0
    pilotboost8: SPB_0
    pilotboost9: SPB_0
    pilotpattern: PILOT_SP3_4
  states: {}
- name: atsc3_pilotgenerator_cc_0_0
  id: atsc3_pilotgenerator_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_32K
    firstsbs: SBS_ON
    guardinterval: GI_4_768
    misomode: MISO_OFF
    misotxid: MISO_TX_1_OF_2
    numpayloadsyms: '18'
    numpreamblesyms: '0'
    outputmode: PILOTGENERATOR_TIME
    paprmode: PAPR_OFF
    pilotboost1: SPB_0
    pilotboost10: SPB_0
    pilotboost11: SPB_0
    pilotboost12: SPB_0
    pilotboost13: SPB_0
    pilotboost14: SPB_0
    pilotboost15: SPB_4
    pilotboost16: SPB_0
    pilotboost2: SPB_4
    pilotboost3: SPB_0
    pilotboost4: SPB_0
    pilotboost5: SPB_0
    pilotboost6: SPB_0
    pilotboost7: SPB_0
    pilotboost8: SPB_0
    pilotboost9: SPB_0
    pilotpattern: PILOT_SP32_2
  states: {}
- name: atsc3_subbootstrap_cc_0
  id: atsc3_subbootstrap_cc
  parameters:
    fftsizeplp0: FFTSIZE_8K
    fftsizeplp1: FFTSIZE_32K
    flen: '100'
    flmode: FLM_SYMBOL_ALIGNED
    frameinterval: MTTN_150
    guardintervalplp0: GI_5_1024
    guardintervalplp1: GI_4_768
    l1bmode: L1_FEC_MODE_1
    numpayloadsymsplp0: '72'
    numpayloadsymsplp1: '18'
    numpreamblesyms: '2'
    outputmode: BOOTSTRAP_INTERPOLATION
    pilotpatternplp0: PILOT_SP3_4
    pilotpatternplp1: PILOT_SP32_2
    showlevels: SHOWLEVELS_OFF
    vclip: '3.3'
  states: {}
- name: atsc3_subframemapper_cc_0
  id: atsc3_subframemapper_cc
  parameters:
    constellationplp01: MOD_64QAM
    constellationplp02: MOD_QPSK
    constellationplp11: MOD_256QAM
    constellationplp12: MOD_QPSK
    credplp0: CRED_0
    credplp1: CRED_0
    fecmodeplp0: PLP_FEC_BCH
    fecmodeplp1: PLP_FEC_BCH
    fftsizeplp0: FFTSIZE_8K
    fftsizeplp1: FFTSIZE_32K
    fimodeplp0: FREQ_ALL_SYMBOLS
    fimodeplp1: FREQ_ALL_SYMBOLS
    firstsbs: SBS_OFF
    flen: '100'
    flmode: FLM_SYMBOL_ALIGNED
    framesizeplp0: FECFRAME_NORMAL
    framesizeplp1: FECFRAME_NORMAL
    guardintervalplp0: GI_5_1024
    guardintervalplp1: GI_4_768
    l1bmode: L1_FEC_MODE_1
    l1dmode: L1_FEC_MODE_1
    llsmodeplp0: LLS_OFF
    llsmodeplp1: LLS_OFF
    misomodeplp0: MISO_OFF
    misomodeplp1: MISO_OFF
    numpayloadsymsplp0: '72'
    numpayloadsymsplp1: '18'
    numpreamblesyms: '2'
    paprmode: PAPR_OFF
    pilotboostplp01: SPB_0
    pilotboostplp010: SPB_0
    pilotboostplp011: SPB_0
    pilotboostplp012: SPB_0
    pilotboostplp013: SPB_0
    pilotboostplp014: SPB_0
    pilotboostplp015: SPB_0
    pilotboostplp016: SPB_0
    pilotboostplp02: SPB_4
    pilotboostplp03: SPB_0
    pilotboostplp04: SPB_0
    pilotboostplp05: SPB_0
    pilotboostplp06: SPB_0
    pilotboostplp07: SPB_0
    pilotboostplp08: SPB_0
    pilotboostplp09: SPB_0
    pilotboostplp11: SPB_0
    pilotboostplp110: SPB_0
    pilotboostplp111: SPB_0
    pilotboostplp112: SPB_0
    pilotboostplp113: SPB_0
    pilotboostplp114: SPB_0
    pilotboostplp115: SPB_4
    pilotboostplp116: SPB_0
    pilotboostplp12: SPB_0
    pilotboostplp13: SPB_0
    pilotboostplp14: SPB_0
    pilotboostplp15: SPB_0
    pilotboostplp16: SPB_0
    pilotboostplp17: SPB_0
    pilotboostplp18: SPB_0
    pilotboostplp19: SPB_0
    pilotpatternplp0: PILOT_SP3_4
    pilotpatternplp1: PILOT_SP32_2
    rateplp0: C9_15
    rateplp1: C12_15
    tiblocksplp0: '2'
    tiblocksplp1: '2'
    tidepthplp0: TI_DEPTH_1024
    tidepthplp1: TI_DEPTH_1024
    tifecblocksmaxplp0: '41'
    tifecblocksmaxplp1: '59'
    tifecblocksplp0: '41'
    tifecblocksplp1: '59'
    timodeplp0: TI_MODE_HYBRID
    timodeplp1: TI_MODE_HYBRID
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/re/ssd/rickmorty5_1sub.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /media/re/ssd/rickmorty4_8sub.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '1024'
    input_size: '8192'
    tagname: ''
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '768'
    input_size: '32768'
    tagname: ''
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, 3000000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: map0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: map1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: map0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: map1
  states: {}

connections:
- [atsc3_alpbbheader_bb_0, '0', atsc3_bbscrambler_bb_0, '0']
- [atsc3_alpbbheader_bb_1, '0', atsc3_bbscrambler_bb_0_0, '0']
- [atsc3_bbscrambler_bb_0, '0', atsc3_bch_bb_0, '0']
- [atsc3_bbscrambler_bb_0_0, '0', atsc3_bch_bb_0_0, '0']
- [atsc3_bch_bb_0, '0', atsc3_ldpc_bb_0, '0']
- [atsc3_bch_bb_0_0, '0', atsc3_ldpc_bb_0_0, '0']
- [atsc3_freqinterleaver_cc_0, '0', atsc3_pilotgenerator_cc_0, '0']
- [atsc3_freqinterleaver_cc_0_0, '0', atsc3_pilotgenerator_cc_0_0, '0']
- [atsc3_interleaver_bb_0, '0', atsc3_modulator_bc_0, '0']
- [atsc3_interleaver_bb_0_0, '0', atsc3_modulator_bc_0_0, '0']
- [atsc3_ldpc_bb_0, '0', atsc3_interleaver_bb_0, '0']
- [atsc3_ldpc_bb_0_0, '0', atsc3_interleaver_bb_0_0, '0']
- [atsc3_modulator_bc_0, '0', atsc3_subframemapper_cc_0, '0']
- [atsc3_modulator_bc_0_0, '0', atsc3_subframemapper_cc_0, '1']
- [atsc3_pilotgenerator_cc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [atsc3_pilotgenerator_cc_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [atsc3_subbootstrap_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [atsc3_subframemapper_cc_0, '0', virtual_sink_0, '0']
- [atsc3_subframemapper_cc_0, '1', virtual_sink_0_0, '0']
- [blocks_file_source_0, '0', atsc3_alpbbheader_bb_0, '0']
- [blocks_file_source_0_0, '0', atsc3_alpbbheader_bb_1, '0']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', atsc3_subbootstrap_cc_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', atsc3_subbootstrap_cc_0, '1']
- [virtual_source_0, '0', atsc3_freqinterleaver_cc_0, '0']
- [virtual_source_0_0, '0', atsc3_freqinterleaver_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-402-g54d199a2
